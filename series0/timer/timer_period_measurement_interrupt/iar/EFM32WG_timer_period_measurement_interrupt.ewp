# IAR project EFM32WG_timer_period_measurement_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFM32WG990F256
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFM32WG_STK3800\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFM32WG990F256
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32WG_timer_period_measurement_interrupt.bin
  ILINK.IlinkOutputFile: EFM32WG_timer_period_measurement_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFM32WG990F256
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_emu.c em_gpio.c em_timer.c
  group platform
    ../../../../../platform/common/src/: sl_syscalls.c
  group Source
    ../src/: main_s0.c
    ../: readme.txt
