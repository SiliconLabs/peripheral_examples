<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_dma_scatter_gather.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_dma_scatter_gather.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_dma_scatter_gather.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_dma_scatter_gather.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_dma_scatter_gather.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_dma_scatter_gather.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_dma_scatter_gather.ewp</path>
  </project>

  <batchBuild/>
</workspace>
