<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_dma_single_looped.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_dma_single_looped.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_dma_single_looped.ewp</path>
  </project>

  <batchBuild/>
</workspace>
