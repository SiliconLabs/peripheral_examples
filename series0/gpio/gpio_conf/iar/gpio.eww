<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_gpio_conf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_gpio_conf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_gpio_conf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_gpio_conf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_gpio_conf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_gpio_conf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_gpio_conf.ewp</path>
  </project>

  <batchBuild/>
</workspace>
