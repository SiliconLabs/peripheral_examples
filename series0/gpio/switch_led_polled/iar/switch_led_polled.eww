<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_switch_led_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
