<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32HG_idac_timer_prs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_idac_timer_prs.ewp</path>
  </project>

  <batchBuild/>
</workspace>
