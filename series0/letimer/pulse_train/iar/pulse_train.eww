<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_pulse_train.ewp</path>
  </project>

  <batchBuild/>
</workspace>
