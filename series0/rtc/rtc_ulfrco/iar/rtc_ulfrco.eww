<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_rtc_ulfrco.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_rtc_ulfrco.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_rtc_ulfrco.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_rtc_ulfrco.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_rtc_ulfrco.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_rtc_ulfrco.ewp</path>
  </project>

  <batchBuild/>
</workspace>
