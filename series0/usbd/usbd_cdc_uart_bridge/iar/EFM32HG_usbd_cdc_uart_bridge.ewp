# IAR project EFM32HG_usbd_cdc_uart_bridge.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32HG322F64 SiliconLaboratories EFM32HG322F64
  ICCARM.CCDefines: STR(x)=#x; EFM32HG322F64
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32HG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\SLSTK3400A_EFM32HG\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\inc\inc_hg; ..\inc; ..\..\..\..\..\platform\middleware\usb_gecko\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32HG322F64
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32HG_usbd_cdc_uart_bridge.bin
  ILINK.IlinkOutputFile: EFM32HG_usbd_cdc_uart_bridge.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFM32HG322F64
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c cdc.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/IAR/: startup_efm32hg.s
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_emu.c em_gpio.c em_timer.c em_usart.c em_dma.c
  group platform
    ../../../../../platform/common/src/: sl_syscalls.c
  group inc
    ../inc/inc_hg/: usbconfig.h
    ../inc/: descriptors.h
  group Source
    ../src/: main_s0.c descriptors.c
    ../: readme.txt
