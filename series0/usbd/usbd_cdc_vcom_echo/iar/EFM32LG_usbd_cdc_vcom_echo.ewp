# IAR project EFM32LG_usbd_cdc_vcom_echo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32LG990F256 SiliconLaboratories EFM32LG990F256
  ICCARM.CCDefines: EFM32LG990F256
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32LG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFM32LG_STK3600\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\inc\inc_series0; ..\inc; ..\..\..\..\..\platform\middleware\usb_gecko\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32LG990F256
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32LG_usbd_cdc_vcom_echo.bin
  ILINK.IlinkOutputFile: EFM32LG_usbd_cdc_vcom_echo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32LG990F256
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../../../../../platform/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_emu.c em_gpio.c em_timer.c
  group inc
    ../inc/inc_series0/: usbconfig.h
    ../inc/: cdc_echo.h descriptors.h
  group Source
    ../src/: main_s0.c cdc_echo.c descriptors.c
    ../: readme.txt
