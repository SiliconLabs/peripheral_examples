<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_usbd_cdc_vcom_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_usbd_cdc_vcom_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_usbd_cdc_vcom_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_usbd_cdc_vcom_echo.ewp</path>
  </project>

  <batchBuild/>
</workspace>
