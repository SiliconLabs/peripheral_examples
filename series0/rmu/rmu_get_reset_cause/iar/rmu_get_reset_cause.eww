<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_rmu_get_reset_cause.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_rmu_get_reset_cause.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_rmu_get_reset_cause.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_rmu_get_reset_cause.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_rmu_get_reset_cause.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_rmu_get_reset_cause.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_rmu_get_reset_cause.ewp</path>
  </project>

  <batchBuild/>
</workspace>
