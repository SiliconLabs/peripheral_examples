<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_servo_adjust.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_servo_adjust.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_servo_adjust.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_servo_adjust.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_servo_adjust.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_servo_adjust.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_servo_adjust.ewp</path>
  </project>

  <batchBuild/>
</workspace>
