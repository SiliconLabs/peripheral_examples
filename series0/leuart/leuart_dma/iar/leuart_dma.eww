<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_leuart_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_leuart_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_leuart_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_leuart_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_leuart_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_leuart_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_leuart_dma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
