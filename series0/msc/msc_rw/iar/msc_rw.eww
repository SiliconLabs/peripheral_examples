<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_msc_rw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_msc_rw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_msc_rw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_msc_rw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_msc_rw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_msc_rw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_msc_rw.ewp</path>
  </project>

  <batchBuild/>
</workspace>
