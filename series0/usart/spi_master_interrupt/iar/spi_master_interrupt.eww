<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32ZG_spi_master_interrupt.ewp</path>
  </project>

  <batchBuild/>
</workspace>
