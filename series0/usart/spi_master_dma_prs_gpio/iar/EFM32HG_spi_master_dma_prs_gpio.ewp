# IAR project EFM32HG_spi_master_dma_prs_gpio.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32HG322F64 SiliconLaboratories EFM32HG322F64
  ICCARM.CCDefines: EFM32HG322F64
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32HG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\SLSTK3400A_EFM32HG\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32HG322F64
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32HG_spi_master_dma_prs_gpio.bin
  ILINK.IlinkOutputFile: EFM32HG_spi_master_dma_prs_gpio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32HG322F64
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/IAR/: startup_efm32hg.s
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_gpio.c em_usart.c em_dma.c em_prs.c em_timer.c
  group Source
    ../src/: main_s0_hg.c
    ../: readme_hg.txt
