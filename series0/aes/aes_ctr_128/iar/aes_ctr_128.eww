<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_aes_ctr_128.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_aes_ctr_128.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_aes_ctr_128.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_aes_ctr_128.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_aes_ctr_128.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_aes_ctr_128.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_aes_ctr_128.ewp</path>
  </project>

  <batchBuild/>
</workspace>
