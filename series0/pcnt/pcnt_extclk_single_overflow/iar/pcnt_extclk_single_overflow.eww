<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_pcnt_extclk_single_overflow.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_pcnt_extclk_single_overflow.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_pcnt_extclk_single_overflow.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_pcnt_extclk_single_overflow.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_pcnt_extclk_single_overflow.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_pcnt_extclk_single_overflow.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_pcnt_extclk_single_overflow.ewp</path>
  </project>

  <batchBuild/>
</workspace>
