<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_adc_single_letimer_prs_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_adc_single_letimer_prs_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_adc_single_letimer_prs_dma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
