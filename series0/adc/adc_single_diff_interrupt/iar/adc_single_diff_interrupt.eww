<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_adc_single_diff_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_adc_single_diff_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_adc_single_diff_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_adc_single_diff_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_adc_single_diff_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_adc_single_diff_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_adc_single_diff_interrupt.ewp</path>
  </project>

  <batchBuild/>
</workspace>
