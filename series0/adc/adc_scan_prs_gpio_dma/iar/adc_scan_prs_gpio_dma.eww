<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_adc_scan_prs_gpio_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_adc_scan_prs_gpio_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_adc_scan_prs_gpio_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_adc_scan_prs_gpio_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_adc_scan_prs_gpio_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_adc_scan_prs_gpio_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_adc_scan_prs_gpio_dma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
