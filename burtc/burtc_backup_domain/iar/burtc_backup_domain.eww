<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG_burtc_backup_domain.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_burtc_backup_domain.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_burtc_backup_domain.ewp</path>
  </project>

  <batchBuild/>
</workspace>
