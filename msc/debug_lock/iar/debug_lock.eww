<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32WG_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG11_debug_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_debug_lock.ewp</path>
  </project>

  <batchBuild/>
</workspace>
