# IAR project EFR32BG12P_rmu_wdog_limited.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG12P332F1024GL125 SiliconLaboratories EFR32BG12P332F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32BG12P332F1024GL125; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG12P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32BG12_BRD4103A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32BG12P332F1024GL125; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG12P_rmu_wdog_limited.bin
  ILINK.IlinkOutputFile: EFR32BG12P_rmu_wdog_limited.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32BG12P332F1024GL125; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetserial.c retargetio.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG12P/Source/IAR/: startup_efr32bg12p.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG12P/Source/: system_efr32bg12p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_cmu.c em_emu.c em_rmu.c em_rtcc.c em_wdog.c em_core.c em_gpio.c em_usart.c
  group Source
    ../src/: main.c
    ../: readme.txt
