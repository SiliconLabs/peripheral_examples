# IAR project EFR32FG14P_rmu_pin_reset_extended.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG14P233F256GM48 SiliconLaboratories EFR32FG14P233F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32FG14P233F256GM48; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG14P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32FG14_BRD4257A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32FG14P233F256GM48; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG14P_rmu_pin_reset_extended.bin
  ILINK.IlinkOutputFile: EFR32FG14P_rmu_pin_reset_extended.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32FG14P233F256GM48; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetserial.c retargetio.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG14P/Source/IAR/: startup_efr32fg14p.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG14P/Source/: system_efr32fg14p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_usart.c em_cmu.c em_emu.c em_rmu.c em_cryotimer.c em_gpio.c
  group Source
    ../src/: main.c
    ../: readme.txt
