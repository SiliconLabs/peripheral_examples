<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_i2s.ewp</path>
  </project>

  <batchBuild/>
</workspace>
