# IAR project EFM32TG11_i2c.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG11B520F128GM80 SiliconLaboratories EFM32TG11B520F128GM80
  ICCARM.CCDefines: EFM32TG11B520F128GM80; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\SLSTK3301A_EFM32TG11\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32TG11B520F128GM80; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32TG11_i2c.bin
  ILINK.IlinkOutputFile: EFM32TG11_i2c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG11B520F128GM80; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/IAR/: startup_efm32tg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/: system_efm32tg11b.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_i2c.c em_cmu.c em_emu.c em_gpio.c
  group Source
    ../src/: main_tg11.c
    ../: readme_tg11.txt
