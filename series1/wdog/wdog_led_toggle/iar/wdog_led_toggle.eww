<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_wdog.ewp</path>
  </project>

  <batchBuild/>
</workspace>
