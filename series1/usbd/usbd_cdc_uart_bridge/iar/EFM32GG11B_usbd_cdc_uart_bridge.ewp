# IAR project EFM32GG11B_usbd_cdc_uart_bridge.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFM32GG11B820F2048GL192
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\inc\inc_gg11; ..\inc; ..\..\..\..\..\platform\middleware\usb_gecko\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFM32GG11B820F2048GL192
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32GG11B_usbd_cdc_uart_bridge.bin
  ILINK.IlinkOutputFile: EFM32GG11B_usbd_cdc_uart_bridge.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFM32GG11B820F2048GL192
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_emu.c em_gpio.c em_timer.c em_usart.c em_ldma.c
  group inc
    ../inc/inc_gg11/: usbconfig.h
    ../inc/: cdc.h descriptors.h
  group Source
    ../src/: main_gg11.c cdc_gg11.c descriptors.c
    ../: readme.txt
