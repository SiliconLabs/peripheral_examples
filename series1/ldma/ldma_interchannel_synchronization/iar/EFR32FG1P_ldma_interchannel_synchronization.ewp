# IAR project EFR32FG1P_ldma_interchannel_synchronization.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG1P133F256GM48 SiliconLaboratories EFR32FG1P133F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32FG1P133F256GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG1P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32FG1_BRD4250A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFR32FG1P133F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG1P_ldma_interchannel_synchronization.bin
  ILINK.IlinkOutputFile: EFR32FG1P_ldma_interchannel_synchronization.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32FG1P133F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG1P/Source/IAR/: startup_efr32fg1p.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG1P/Source/: system_efr32fg1p.c
  group emlib
    ../../../../../platform/emlib/src/: em_core.c em_cmu.c em_ldma.c em_gpio.c em_system.c em_emu.c em_prs.c
  group Source
    ./: readme.txt
    ../src/: main.c
