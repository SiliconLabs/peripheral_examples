<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11B_dsp_lib_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_dsp_lib_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_dsp_lib_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_dsp_lib_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1P_dsp_lib_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_dsp_lib_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_dsp_lib_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_dsp_lib_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_dsp_lib_fft.ewp</path>
  </project>

  <batchBuild/>
</workspace>
