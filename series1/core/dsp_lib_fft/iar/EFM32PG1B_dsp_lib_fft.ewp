# IAR project EFM32PG1B_dsp_lib_fft.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFM32PG1B200F256GM48; RETARGET_VCOM; __FPU_PRESENT; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG1B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\SLSTK3401A_EFM32PG\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\CMSIS\DSP\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFM32PG1B200F256GM48; RETARGET_VCOM; __FPU_PRESENT; ARM_MATH_CM4
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32PG1B_dsp_lib_fft.bin
  ILINK.IlinkOutputFile: EFM32PG1B_dsp_lib_fft.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFM32PG1B200F256GM48; RETARGET_VCOM; __FPU_PRESENT; ARM_MATH_CM4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG1B/Source/IAR/: startup_efm32pg1b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group DSP
    ../../../../../platform/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../platform/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
    ../../../../../platform/CMSIS/DSP/Source/TransformFunctions/: arm_rfft_f32.c arm_rfft_init_f32.c arm_bitreversal.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_emu.c em_cmu.c em_adc.c em_gpio.c
  group Source
    ../src/: main.c
    ../: readme.txt
