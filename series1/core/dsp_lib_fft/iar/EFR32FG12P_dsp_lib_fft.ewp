# IAR project EFR32FG12P_dsp_lib_fft.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG12P433F1024GL125 SiliconLaboratories EFR32FG12P433F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32FG12P433F1024GL125; RETARGET_VCOM; __FPU_PRESENT; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG12P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32FG12_BRD4253A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\CMSIS\DSP\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32FG12P433F1024GL125; RETARGET_VCOM; __FPU_PRESENT; ARM_MATH_CM4
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG12P_dsp_lib_fft.bin
  ILINK.IlinkOutputFile: EFR32FG12P_dsp_lib_fft.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32FG12P433F1024GL125; RETARGET_VCOM; __FPU_PRESENT; ARM_MATH_CM4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG12P/Source/IAR/: startup_efr32fg12p.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG12P/Source/: system_efr32fg12p.c
  group DSP
    ../../../../../platform/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../platform/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
    ../../../../../platform/CMSIS/DSP/Source/TransformFunctions/: arm_rfft_f32.c arm_rfft_init_f32.c arm_bitreversal.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_emu.c em_cmu.c em_adc.c em_gpio.c
  group Source
    ../src/: main.c
    ../: readme.txt
