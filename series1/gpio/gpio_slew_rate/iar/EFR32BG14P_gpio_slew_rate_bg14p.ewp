# IAR project EFR32BG14P_gpio_slew_rate_bg14p.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG14P732F256GM48 SiliconLaboratories EFR32BG14P732F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32BG14P732F256GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG14P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32BG14_BRD4105A\config; ..\..\..\..\..\hardware\kit\common\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32BG14P732F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG14P_gpio_slew_rate_bg14p.bin
  ILINK.IlinkOutputFile: EFR32BG14P_gpio_slew_rate_bg14p.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32BG14P732F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG14P/Source/IAR/: startup_efr32bg14p.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG14P/Source/: system_efr32bg14p.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_wdog.c em_rmu.c em_cmu.c em_emu.c em_gpio.c em_rtcc.c em_core.c em_ldma.c em_prs.c em_system.c em_usart.c em_timer.c em_letimer.c
  group Source
    ../src/: main_gpio_slew_rate.c
    ../: readme.txt
