# IAR project EFR32BG12P_gpio_slew_rate_bg12p.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG12P332F1024GL125 SiliconLaboratories EFR32BG12P332F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32BG12P332F1024GL125
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG12P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32BG12_BRD4103A\config; ..\..\..\..\..\hardware\kit\common\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32BG12P332F1024GL125
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG12P_gpio_slew_rate_bg12p.bin
  ILINK.IlinkOutputFile: EFR32BG12P_gpio_slew_rate_bg12p.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32BG12P332F1024GL125
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG12P/Source/IAR/: startup_efr32bg12p.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG12P/Source/: system_efr32bg12p.c
  group emlib
    ../../../../../platform/emlib/src/: em_wdog.c em_rmu.c em_cmu.c em_emu.c em_gpio.c em_rtcc.c em_core.c em_ldma.c em_prs.c em_system.c em_usart.c em_timer.c em_letimer.c
  group platform
    ../../../../../platform/common/src/: sl_syscalls.c
  group Source
    ../src/: main_gpio_slew_rate.c
    ../: readme.txt
