# IAR project EFM32TG11B_gpio_slew_rate_tg11b.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG11B520F128GM80 SiliconLaboratories EFM32TG11B520F128GM80
  ICCARM.CCDefines: STR(x)=#x; EFM32TG11B520F128GM80
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\SLSTK3301A_EFM32TG11\config; ..\..\..\..\..\hardware\kit\common\bsp
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32TG11B520F128GM80
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32TG11B_gpio_slew_rate_tg11b.bin
  ILINK.IlinkOutputFile: EFM32TG11B_gpio_slew_rate_tg11b.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFM32TG11B520F128GM80
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/IAR/: startup_efm32tg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/: system_efm32tg11b.c
  group emlib
    ../../../../../platform/emlib/src/: em_wdog.c em_rmu.c em_cmu.c em_emu.c em_gpio.c em_rtcc.c em_core.c em_ldma.c em_prs.c em_system.c em_usart.c em_timer.c em_letimer.c
  group platform
    ../../../../../platform/common/src/: sl_syscalls.c
  group Source
    ../src/: main_gpio_slew_rate.c
    ../: readme.txt
