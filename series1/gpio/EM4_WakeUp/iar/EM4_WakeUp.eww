<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_EM4_WakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_EM4_WakeUp.ewp</path>
  </project>

  <batchBuild/>
</workspace>
