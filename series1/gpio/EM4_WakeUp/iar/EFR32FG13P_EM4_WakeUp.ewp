# IAR project EFR32FG13P_EM4_WakeUp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG13P233F512GM48 SiliconLaboratories EFR32FG13P233F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32FG13P233F512GM48; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG13P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32FG13_BRD4256A\config; ..\..\..\..\..\hardware\kit\EFR32FG13_BRD4256A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32FG13P233F512GM48; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG13P_EM4_WakeUp.bin
  ILINK.IlinkOutputFile: EFR32FG13P_EM4_WakeUp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32FG13P233F512GM48; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Drivers
    ../../../../../hardware/kit/common/drivers/: mx25flash_spi.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG13P/Source/IAR/: startup_efr32fg13p.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG13P/Source/: system_efr32fg13p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_gpio.c em_emu.c em_rmu.c em_usart.c
  group Source
    ../src/: main_efr32.c
    ../: readme_s1.txt
