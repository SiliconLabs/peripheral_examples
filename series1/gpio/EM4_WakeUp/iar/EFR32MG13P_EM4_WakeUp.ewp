# IAR project EFR32MG13P_EM4_WakeUp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG13P632F512GM48 SiliconLaboratories EFR32MG13P632F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32MG13P632F512GM48; RETARGET_VCOM; MX25_LOC_RX=_USART_ROUTELOC0_RXLOC_LOC11; MX25_LOC_SCLK=_USART_ROUTELOC0_CLKLOC_LOC11; MX25_LOC_TX=_USART_ROUTELOC0_TXLOC_LOC11
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG13P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG13_BRD4159A\config; ..\..\..\..\..\hardware\kit\EFR32MG13_BRD4159A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG13P632F512GM48; RETARGET_VCOM; MX25_LOC_RX=_USART_ROUTELOC0_RXLOC_LOC11; MX25_LOC_SCLK=_USART_ROUTELOC0_CLKLOC_LOC11; MX25_LOC_TX=_USART_ROUTELOC0_TXLOC_LOC11
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG13P_EM4_WakeUp.bin
  ILINK.IlinkOutputFile: EFR32MG13P_EM4_WakeUp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG13P632F512GM48; RETARGET_VCOM; MX25_LOC_RX=_USART_ROUTELOC0_RXLOC_LOC11; MX25_LOC_SCLK=_USART_ROUTELOC0_CLKLOC_LOC11; MX25_LOC_TX=_USART_ROUTELOC0_TXLOC_LOC11
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Drivers
    ../../../../../hardware/kit/common/drivers/: mx25flash_spi.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG13P/Source/IAR/: startup_efr32mg13p.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG13P/Source/: system_efr32mg13p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_gpio.c em_emu.c em_rmu.c em_usart.c
  group platform
    ../../../../../platform/common/src/: sl_syscalls.c
  group Source
    ../src/: main_efr32.c
    ../: readme_s1.txt
