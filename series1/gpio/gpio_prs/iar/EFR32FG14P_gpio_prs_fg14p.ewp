# IAR project EFR32FG14P_gpio_prs_fg14p.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG14P233F256GM48 SiliconLaboratories EFR32FG14P233F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32FG14P233F256GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG14P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32FG14_BRD4257A\config; ..\..\..\..\..\hardware\kit\common\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32FG14P233F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG14P_gpio_prs_fg14p.bin
  ILINK.IlinkOutputFile: EFR32FG14P_gpio_prs_fg14p.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32FG14P233F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG14P/Source/IAR/: startup_efr32fg14p.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG14P/Source/: system_efr32fg14p.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_cmu.c em_core.c em_gpio.c em_emu.c em_prs.c em_system.c
  group Source
    ../src/: main_gpio_prs.c
    ../: readme.txt
