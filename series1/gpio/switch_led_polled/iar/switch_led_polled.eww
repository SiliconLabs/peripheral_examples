<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_switch_led_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
