# IAR project BGM121_spi_master_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: BGM121A256V2 SiliconLaboratories BGM121A256V2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; BGM121A256V2
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG1B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\BGM11_BRD4302A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: BGM121A256V2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: BGM121_spi_master_interrupt.bin
  ILINK.IlinkOutputFile: BGM121_spi_master_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; BGM121A256V2
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG1B/Source/IAR/: startup_efr32bg1b.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG1B/Source/: system_efr32bg1b.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_usart.c
  group Source
    ../src/: main_s1_xg1_xg13_xg14.c
    ../: readme.txt
