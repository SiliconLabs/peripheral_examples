# IAR project EFM32PG1B_spi_master_dma_prs_letimer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFM32PG1B200F256GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG1B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\SLSTK3401A_EFM32PG\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFM32PG1B200F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32PG1B_spi_master_dma_prs_letimer.bin
  ILINK.IlinkOutputFile: EFM32PG1B_spi_master_dma_prs_letimer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFM32PG1B200F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG1B/Source/IAR/: startup_efm32pg1b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_emu.c em_cmu.c em_gpio.c em_usart.c em_ldma.c em_prs.c em_letimer.c
  group Source
    ../src/: main_s1_pg1_efr.c
    ../: readme_pg1_efr.txt
