# IAR project EFR32MG12_spi_master_dma_prs_letimer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG12P432F1024GL125 SiliconLaboratories EFR32MG12P432F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32MG12P432F1024GL125
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG12P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG12_BRD4164A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG12P432F1024GL125
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG12_spi_master_dma_prs_letimer.bin
  ILINK.IlinkOutputFile: EFR32MG12_spi_master_dma_prs_letimer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG12P432F1024GL125
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG12P/Source/IAR/: startup_efr32mg12p.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG12P/Source/: system_efr32mg12p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_emu.c em_cmu.c em_gpio.c em_usart.c em_ldma.c em_prs.c em_letimer.c
  group platform
    ../../../../../platform/common/src/: sl_syscalls.c
  group Source
    ../src/: main_s1_xg12.c
    ../: readme_xg12.txt
