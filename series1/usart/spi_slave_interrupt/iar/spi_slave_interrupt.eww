<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_spi_slave_interrupt.ewp</path>
  </project>

  <batchBuild/>
</workspace>
