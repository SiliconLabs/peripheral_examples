<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG12_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13_rtcc_wake_em4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14_rtcc_wake_em4.ewp</path>
  </project>

  <batchBuild/>
</workspace>
