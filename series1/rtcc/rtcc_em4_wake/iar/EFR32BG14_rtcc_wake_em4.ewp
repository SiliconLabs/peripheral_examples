# IAR project EFR32BG14_rtcc_wake_em4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG14P732F256GM48 SiliconLaboratories EFR32BG14P732F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32BG14P732F256GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG14P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32BG14_BRD4105A\config; ..\..\..\..\..\hardware\kit\common\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32BG14P732F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG14_rtcc_wake_em4.bin
  ILINK.IlinkOutputFile: EFR32BG14_rtcc_wake_em4.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32BG14P732F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG14P/Source/IAR/: startup_efr32bg14p.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG14P/Source/: system_efr32bg14p.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_emu.c em_gpio.c em_rmu.c em_rtcc.c em_system.c
  group Source
    ../src/: main_rtcc_em4_wake.c
    ../: readme.txt
