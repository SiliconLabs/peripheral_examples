# IAR project EFR32BG13P_debug_lock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG13P632F512GM48 SiliconLaboratories EFR32BG13P632F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32BG13P632F512GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG13P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32BG13_BRD4104A\config; ..\..\..\..\..\hardware\kit\EFR32BG13_BRD4104A\config; ..\..\..\..\..\hardware\kit\common\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32BG13P632F512GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG13P_debug_lock.bin
  ILINK.IlinkOutputFile: EFR32BG13P_debug_lock.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32BG13P632F512GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG13P/Source/IAR/: startup_efr32bg13p.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG13P/Source/: system_efr32bg13p.c
  group emlib
    ../../../../../platform/emlib/src/: em_rmu.c em_cmu.c em_msc.c em_system.c em_core.c
  group Source
    ../: readme_sysresetreq.txt
    ../src/: main_sysresetreq.c
