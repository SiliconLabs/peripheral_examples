# IAR project EFR32FG14P_debug_lock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG14P233F256GM48 SiliconLaboratories EFR32FG14P233F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32FG14P233F256GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG14P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32FG14_BRD4257A\config; ..\..\..\..\..\hardware\kit\EFR32FG14_BRD4257A\config; ..\..\..\..\..\hardware\kit\common\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFR32FG14P233F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG14P_debug_lock.bin
  ILINK.IlinkOutputFile: EFR32FG14P_debug_lock.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32FG14P233F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG14P/Source/IAR/: startup_efr32fg14p.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG14P/Source/: system_efr32fg14p.c
  group emlib
    ../../../../../platform/emlib/src/: em_rmu.c em_cmu.c em_msc.c em_system.c em_core.c
  group Source
    ../: readme_SYSRESETREQ.txt
    ../src/: main_sysresetreq.c
