<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11B_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11B_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_logic_unit.ewp</path>
  </project>

  <batchBuild/>
</workspace>
