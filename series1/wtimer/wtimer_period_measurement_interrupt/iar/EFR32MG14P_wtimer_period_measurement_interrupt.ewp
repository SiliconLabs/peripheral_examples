# IAR project EFR32MG14P_wtimer_period_measurement_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG14P733F256GM48 SiliconLaboratories EFR32MG14P733F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32MG14P733F256GM48
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG14P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG14_BRD4169B\config; ..\..\..\..\..\hardware\kit\EFR32MG14_BRD4169B\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFR32MG14P733F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG14P_wtimer_period_measurement_interrupt.bin
  ILINK.IlinkOutputFile: EFR32MG14P_wtimer_period_measurement_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32MG14P733F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG14P/Source/IAR/: startup_efr32mg14p.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG14P/Source/: system_efr32mg14p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_emu.c em_gpio.c em_timer.c
  group Source
    ../src/: main_s1.c
    ../: readme.txt
