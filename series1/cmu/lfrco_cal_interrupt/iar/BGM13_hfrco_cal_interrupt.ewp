# IAR project BGM13_hfrco_cal_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: BGM13P32F512GA SiliconLaboratories BGM13P32F512GA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; BGM13P32F512GA
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\BGM13\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\BGM13_BRD4306B\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: BGM13P32F512GA
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: BGM13_hfrco_cal_interrupt.bin
  ILINK.IlinkOutputFile: BGM13_hfrco_cal_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; BGM13P32F512GA
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/BGM13/Source/IAR/: startup_bgm13.s
    ../../../../../platform/Device/SiliconLabs/BGM13/Source/: system_bgm13.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_gpio.c
  group Source
    ../src/: main_efr32_efm32jg_pg.c
    ../: readme.txt
