# IAR project EFR32MG13_lfrco_cal_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG13P733F512GM48 SiliconLaboratories EFR32MG13P733F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32MG13P733F512GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG13P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG13_BRD4158A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG13P733F512GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG13_lfrco_cal_interrupt.bin
  ILINK.IlinkOutputFile: EFR32MG13_lfrco_cal_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG13P733F512GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG13P/Source/IAR/: startup_efr32mg13p.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG13P/Source/: system_efr32mg13p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_gpio.c
  group Source
    ../src/: main_efr32_efm32jg_pg.c
    ../: readme.txt
