<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13_hfrco_cal_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1_hfrco_cal_interrupt.ewp</path>
  </project>

  <batchBuild/>
</workspace>
