# IAR project BGM1211_lfrco_cal_polled.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG1B232F256GM48 SiliconLaboratories EFR32BG1B232F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFR32BG1B232F256GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG1B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\BGM11_BRD4302A\config; ..\..\..\..\..\hardware\kit\BGM11_BRD4302A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32BG1B232F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: BGM1211_lfrco_cal_polled.bin
  ILINK.IlinkOutputFile: BGM1211_lfrco_cal_polled.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32BG1B232F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG1B/Source/IAR/: startup_efr32bg1b.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG1B/Source/: system_efr32bg1b.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_cmu.c em_cryotimer.c em_emu.c em_gpio.c
  group Source
    ../src/: main_efr32_efm32xg1.c
    ../: readme.txt
