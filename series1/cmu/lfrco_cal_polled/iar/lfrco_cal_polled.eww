<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BGM111_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\BGM113_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\BGM121_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\BGM13_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG11_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13_lfrco_cal_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1_lfrco_cal_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
