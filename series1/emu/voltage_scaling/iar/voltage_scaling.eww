<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11B_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11B_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_voltage_scaling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_voltage_scaling.ewp</path>
  </project>

  <batchBuild/>
</workspace>
