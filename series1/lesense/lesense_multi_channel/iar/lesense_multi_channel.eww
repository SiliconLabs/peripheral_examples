<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_lesense_multi_channel.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_lesense_multi_channel.ewp</path>
  </project>

  <batchBuild/>
</workspace>
