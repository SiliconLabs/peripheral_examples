# IAR project EFR32MG1P_cryotimer_lfxo_ret_em4exit.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P232F256GM48 SiliconLaboratories EFR32MG1P232F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32MG1P232F256GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG1_BRD4151A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFR32MG1P232F256GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG1P_cryotimer_lfxo_ret_em4exit.bin
  ILINK.IlinkOutputFile: EFR32MG1P_cryotimer_lfxo_ret_em4exit.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32MG1P232F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG1P/Source/IAR/: startup_efr32mg1p.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_emu.c em_gpio.c em_cryotimer.c em_rmu.c
  group Source
    ../src/: main.c
    ../: readme.txt
