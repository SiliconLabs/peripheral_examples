<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11B_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11B_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_gpcrc_software.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_gpcrc_software.ewp</path>
  </project>

  <batchBuild/>
</workspace>
