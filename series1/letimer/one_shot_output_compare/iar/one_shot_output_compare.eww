<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11B_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11B_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_one_shot_output_compare.ewp</path>
  </project>

  <batchBuild/>
</workspace>
