<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG11_rmu_wdog_extended.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_rmu_wdog_extended.ewp</path>
  </project>

  <batchBuild/>
</workspace>
