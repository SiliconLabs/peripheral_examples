<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_rmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_rmu.ewp</path>
  </project>

  <batchBuild/>
</workspace>
