# IAR project EFR32BG1P_rmu_limited.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG1P232F256GM48 SiliconLaboratories EFR32BG1P232F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32BG1P232F256GM48; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG1P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32BG1_BRD4100A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFR32BG1P232F256GM48; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG1P_rmu_limited.bin
  ILINK.IlinkOutputFile: EFR32BG1P_rmu_limited.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32BG1P232F256GM48; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG1P/Source/IAR/: startup_efr32bg1p.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG1P/Source/: system_efr32bg1p.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_rmu.c em_rtcc.c em_system.c em_usart.c em_wdog.c
  group Source
    ../src/: main.c
    ../: readme.txt
