# IAR project EFR32BG12P_pcnt_single_oversampling_underflow.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG12P332F1024GL125 SiliconLaboratories EFR32BG12P332F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32BG12P332F1024GL125; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG12P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32BG12_BRD4103A\config; ..\..\..\..\..\hardware\kit\EFR32BG12_BRD4103A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFR32BG12P332F1024GL125; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG12P_pcnt_single_oversampling_underflow.bin
  ILINK.IlinkOutputFile: EFR32BG12P_pcnt_single_oversampling_underflow.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32BG12P332F1024GL125; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG12P/Source/IAR/: startup_efr32bg12p.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG12P/Source/: system_efr32bg12p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_pcnt.c em_gpio.c em_prs.c em_emu.c
  group BSP
    ../../../../../hardware/kit/common/bsp/src/: bsp_stk_leds.c
  group Source
    ../src/: main_s1.c
    ../: readme.txt
