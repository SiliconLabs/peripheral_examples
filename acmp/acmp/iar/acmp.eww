<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_acmp.ewp</path>
  </project>

  <batchBuild/>
</workspace>
