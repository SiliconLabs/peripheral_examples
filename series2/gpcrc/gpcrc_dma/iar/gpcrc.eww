<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG27_gpcrc_dma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
