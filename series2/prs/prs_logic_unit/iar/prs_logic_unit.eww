<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG21_prs_logic_unit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32xG22_prs_logic_unit.ewp</path>
  </project>

  <batchBuild/>
</workspace>
