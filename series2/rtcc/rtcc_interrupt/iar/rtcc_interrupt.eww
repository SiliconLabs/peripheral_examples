<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG21_rtcc_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_rtcc_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_rtcc_interrupt.ewp</path>
  </project>

  <batchBuild/>
</workspace>
