<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG21_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32xG22_pulse_train.ewp</path>
  </project>

  <batchBuild/>
</workspace>
