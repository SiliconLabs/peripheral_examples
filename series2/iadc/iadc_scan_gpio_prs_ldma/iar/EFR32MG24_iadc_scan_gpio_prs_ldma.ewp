# IAR project EFR32MG24_iadc_scan_gpio_prs_ldma.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG24A010F1536GM48 SiliconLaboratories EFR32MG24A010F1536GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32MG24A010F1536GM48
  ICCARM.CCDiagSuppress: Pe188
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG24_BRD4186A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG24A010F1536GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG24_iadc_scan_gpio_prs_ldma.bin
  ILINK.IlinkOutputFile: EFR32MG24_iadc_scan_gpio_prs_ldma.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG24A010F1536GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG24A010F1536GM48
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG24/Source/IAR/: startup_efr32mg24.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG24/Source/: system_efr32mg24.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_iadc.c em_ldma.c em_prs.c em_system.c
  group Source
    ../src/: main_scan_gpio_prs_ldma.c
    ../: readme.txt
