<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_iadc_single_differential_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_iadc_single_differential_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_iadc_single_differential_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_iadc_single_differential_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_iadc_single_differential_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_iadc_single_differential_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_iadc_single_differential_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
