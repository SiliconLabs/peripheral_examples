<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_acmp_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_acmp_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_acmp_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_acmp_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_acmp_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_acmp_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
