# IAR project se_ecdsa.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A010F1024IM32 SiliconLaboratories EFR32MG21A010F1024IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: EFR32MG21A010F1024IM32; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_ENTROPY_FORCE_SHA256; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG21\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\util\third_party\mbedtls\include; ..\..\..\..\..\util\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\include; ..\..\..\..\..\util\third_party\crypto\sl_component\se_manager\src; ..\..\..\..\..\util\third_party\crypto\sl_component\se_manager\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\EFR32MG21_BRD4181A\config; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: se_ecdsa.bin
  ILINK.IlinkOutputFile: se_ecdsa.out
  ILINK.IlinkIcfFile: ..\src\se_ecdsa.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32MG21A010F1024IM32; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_ENTROPY_FORCE_SHA256; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: as above
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG21/Source/IAR/: startup_efr32mg21.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG21/Source/: system_efr32mg21.c
  group mbedtls
    ../../../../../util/third_party/mbedtls/library/: aes.c asn1parse.c asn1write.c bignum.c ctr_drbg.c ecdsa.c ecp.c ecp_curves.c entropy.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c platform_util.c ripemd160.c sha1.c sha256.c sha512.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_gpio.c em_se.c em_system.c em_usart.c
  group sl_crypto
    ../../../../../util/third_party/mbedtls/sl_crypto/src/: se_aes.c se_ecp.c se_management.c se_sha.c se_trng.c shax.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group Source
    ../: readme.txt
    ../src/: main.c
