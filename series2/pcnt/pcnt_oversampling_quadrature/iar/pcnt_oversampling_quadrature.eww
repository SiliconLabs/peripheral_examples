<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG23_pcnt_oversampling_quadrature.ewp</path>
  </project>

  <batchBuild/>
</workspace>
