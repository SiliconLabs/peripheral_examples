<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG23_pcnt_single_oversampling_overflow.ewp</path>
  </project>

  <batchBuild/>
</workspace>
