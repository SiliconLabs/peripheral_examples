<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG23_pcnt_single_oversampling_underflow.ewp</path>
  </project>

  <batchBuild/>
</workspace>
