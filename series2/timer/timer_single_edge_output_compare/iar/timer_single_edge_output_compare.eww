<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG21_timer_single_edge_output_compare.ewp</path>
  </project>

  <batchBuild/>
</workspace>
