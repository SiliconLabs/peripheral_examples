<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_timer_single_pulse_generation_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_timer_single_pulse_generation_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_timer_single_pulse_generation_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_timer_single_pulse_generation_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_timer_single_pulse_generation_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_timer_single_pulse_generation_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_timer_single_pulse_generation_interrupt.ewp</path>
  </project>

  <batchBuild/>
</workspace>
