<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG21_msc_rw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32xG22_msc_rw.ewp</path>
  </project>

  <batchBuild/>
</workspace>
