# IAR project EFR32FG25_msc_page_lock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG25B222F1920IM56 SiliconLaboratories EFR32FG25B222F1920IM56
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32FG25B222F1920IM56
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG25\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\kit\EFR32FG25_BRD4270B; ..\..\..\kit\common\bsp; ..\..\..\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32FG25B222F1920IM56
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG25_msc_page_lock.bin
  ILINK.IlinkOutputFile: EFR32FG25_msc_page_lock.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32FG25B222F1920IM56
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32FG25B222F1920IM56
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG25/Source/IAR/: startup_efr32fg25.s
    ../CMSIS/EFR32xG25/: custom_system_efr32xg25.c
  group emlib
    ../../../../../platform/emlib/src/: em_msc.c em_system.c
  group platform
    ../../../../../platform/common/src/: sl_syscalls.c
  group Source
    ../src/: main.c
    ../: readme.txt
