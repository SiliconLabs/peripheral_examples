<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_msc_page_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_msc_page_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_msc_page_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_msc_page_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_msc_page_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_msc_page_lock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_msc_page_lock.ewp</path>
  </project>

  <batchBuild/>
</workspace>
