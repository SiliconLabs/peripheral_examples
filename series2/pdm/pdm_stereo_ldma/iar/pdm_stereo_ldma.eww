<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG22_pdm_stereo_ldma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG27_pdm_stereo_ldma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
