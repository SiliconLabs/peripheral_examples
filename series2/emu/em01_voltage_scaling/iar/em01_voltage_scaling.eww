<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG22_em01_voltage_scaling.ewp</path>
  </project>

  <batchBuild/>
</workspace>
