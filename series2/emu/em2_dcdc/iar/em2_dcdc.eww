<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32ZG23_em2_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_em2_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG25_em2_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_em2_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG27_em2_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_em2_dcdc.ewp</path>
  </project>

  <batchBuild/>
</workspace>
