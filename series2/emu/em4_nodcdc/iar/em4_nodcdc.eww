<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG23_em4_nodcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG23_em4_nodcdc.ewp</path>
  </project>

  <batchBuild/>
</workspace>
