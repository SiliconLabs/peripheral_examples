<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_em0_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_em0_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_em0_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_em0_dcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_em0_dcdc.ewp</path>
  </project>

  <batchBuild/>
</workspace>
