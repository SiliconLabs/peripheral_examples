<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG22_euart_dma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
