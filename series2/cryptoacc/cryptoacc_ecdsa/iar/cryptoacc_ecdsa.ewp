# IAR project cryptoacc_ecdsa.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG22C224F512IM40 SiliconLaboratories EFR32MG22C224F512IM40
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: EFR32MG22C224F512IM40; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_CONFIG_FILE="cryptoacc-acceleration.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG22\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\util\third_party\mbedtls\configs; ..\..\..\..\..\util\third_party\mbedtls\include; ..\..\..\..\..\util\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\include; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src\cryptoacc\src; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src\cryptoacc\include; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\EFR32MG22_BRD4182A\config; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cryptoacc_ecdsa.bin
  ILINK.IlinkOutputFile: cryptoacc_ecdsa.out
  ILINK.IlinkIcfFile: ..\src\cryptoacc_ecdsa.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32MG22C224F512IM40; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_CONFIG_FILE="cryptoacc-acceleration.h"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: as above
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG22/Source/IAR/: startup_efr32mg22.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG22/Source/: system_efr32mg22.c
  group mbedtls
    ../../../../../util/third_party/mbedtls/library/: aes.c asn1parse.c asn1write.c bignum.c ctr_drbg.c ecdsa.c ecp.c ecp_curves.c entropy.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c ripemd160.c sha1.c sha256.c sha512.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_system.c em_usart.c
  group sl_crypto
    ../../../../../util/third_party/mbedtls/sl_crypto/src/: cryptoacc_aes.c cryptoacc_ecp.c cryptoacc_management.c cryptoacc_sha.c cryptoacc_trng.c shax.c
    ../../../../../util/third_party/mbedtls/sl_crypto/src/cryptoacc/src/: ba414ep_config.c ba431_config.c cryptodma_internal.c cryptolib_types.c sx_aes.c sx_blk_cipher.c sx_ecc_curves.c sx_ecc_keygen_alg.c sx_ecdsa_alg.c sx_hash.c sx_math.c sx_memcmp.c sx_memcpy.c sx_rng.c sx_trng.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group Source
    ../: readme.txt
    ../src/: main.c
