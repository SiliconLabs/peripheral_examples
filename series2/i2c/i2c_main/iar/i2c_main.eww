<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG23_i2c_main.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32xG21_i2c_main.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32xG22_i2c_main.ewp</path>
  </project>

  <batchBuild/>
</workspace>
