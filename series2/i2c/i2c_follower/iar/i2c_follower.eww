<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG23_i2c_follower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_i2c_follower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_i2c_follower.ewp</path>
  </project>

  <batchBuild/>
</workspace>
