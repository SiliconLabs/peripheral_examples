# IAR project EFR32ZG28_vdac_timer_dma_waveform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32ZG28B312F1024IM68 SiliconLaboratories EFR32ZG28B312F1024IM68
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32ZG28B312F1024IM68
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32ZG28\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\kit\EFR32ZG28_BRD4400B; ..\..\..\kit\common\bsp; ..\..\..\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32ZG28B312F1024IM68
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32ZG28_vdac_timer_dma_waveform.bin
  ILINK.IlinkOutputFile: EFR32ZG28_vdac_timer_dma_waveform.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32ZG28B312F1024IM68
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32ZG28B312F1024IM68
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32ZG28/Source/IAR/: startup_efr32zg28.s
    ../../../../../platform/Device/SiliconLabs/EFR32ZG28/Source/: system_efr32zg28.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_system.c em_timer.c em_vdac.c
  group Drivers
    ../../../kit/common/drivers/: mx25flash_spi.c
  group Source
    ../src/: main_vdac_timer_dma_waveform.c
    ../: readme.txt
