<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_vdac_timer_dma_waveform.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_vdac_timer_dma_waveform.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_vdac_timer_dma_waveform.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_vdac_timer_dma_waveform.ewp</path>
  </project>

  <batchBuild/>
</workspace>
