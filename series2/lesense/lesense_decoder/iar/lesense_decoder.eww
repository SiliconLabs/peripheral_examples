<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_lesense_decoder.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_lesense_decoder.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_lesense_decoder.ewp</path>
  </project>

  <batchBuild/>
</workspace>
