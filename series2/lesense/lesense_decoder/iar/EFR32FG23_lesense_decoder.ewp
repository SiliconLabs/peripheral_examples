# IAR project EFR32FG23_lesense_decoder.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG23A010F512GM48 SiliconLaboratories EFR32FG23A010F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32FG23A010F512GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG23\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32FG23_BRD4263B\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32FG23A010F512GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG23_lesense_decoder.bin
  ILINK.IlinkOutputFile: EFR32FG23_lesense_decoder.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32FG23A010F512GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32FG23A010F512GM48
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG23/Source/IAR/: startup_efr32fg23.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG23/Source/: system_efr32fg23.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_acmp.c em_core.c em_cmu.c em_emu.c em_gpio.c em_iadc.c em_lesense.c em_usart.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: mx25flash_spi.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_stk_leds.c
  group Source
    ../src/: main.c
    ../: readme.txt
