<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_ldma_ping_pong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_ldma_ping_pong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_ldma_ping_pong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_ldma_ping_pong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_ldma_ping_pong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_ldma_ping_pong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_ldma_ping_pong.ewp</path>
  </project>

  <batchBuild/>
</workspace>
