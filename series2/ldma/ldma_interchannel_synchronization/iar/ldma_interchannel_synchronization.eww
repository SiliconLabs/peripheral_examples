<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG21_ldma_interchannel_synchronization.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_ldma_interchannel_synchronization.ewp</path>
  </project>

  <batchBuild/>
</workspace>
