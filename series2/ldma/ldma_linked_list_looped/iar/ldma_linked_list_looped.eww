<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG21_ldma_linked_list_looped.ewp</path>
  </project>

  <batchBuild/>
</workspace>
