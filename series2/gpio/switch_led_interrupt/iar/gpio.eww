<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_switch_led_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_switch_led_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_switch_led_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_switch_led_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_switch_led_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_switch_led_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_switch_led_interrupt.ewp</path>
  </project>

  <batchBuild/>
</workspace>
