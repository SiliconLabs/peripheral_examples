<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG21_gpio_prs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_gpio_prs.ewp</path>
  </project>

  <batchBuild/>
</workspace>
