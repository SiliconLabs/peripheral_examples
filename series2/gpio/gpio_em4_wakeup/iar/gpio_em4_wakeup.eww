<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG21_gpio_em4_wakeup.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32xG22_gpio_em4_wakeup.ewp</path>
  </project>

  <batchBuild/>
</workspace>
