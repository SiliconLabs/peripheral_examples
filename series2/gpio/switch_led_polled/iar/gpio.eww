<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG23_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_switch_led_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
