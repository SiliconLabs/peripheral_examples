# IAR project EFR32MG21_gpio_int.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A010F1024IM32 SiliconLaboratories EFR32MG21A010F1024IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: EFR32MG21A010F1024IM32; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG21\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG21_BRD4181A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG21A010F1024IM32; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG21_gpio_int.bin
  ILINK.IlinkOutputFile: EFR32MG21_gpio_int.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32MG21A010F1024IM32; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG21A010F1024IM32; RETARGET_VCOM
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG21/Source/IAR/: startup_efr32mg21.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG21/Source/: system_efr32mg21.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_emu.c em_gpio.c em_iadc.c em_prs.c em_system.c em_core.c em_timer.c em_usart.c
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group Source
    ../src/: main_gpio_int_s2_xg21.c
    ../: readme_xg21.txt
