<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG24_eusart_async_autobaud.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG23_eusart_async_autobaud.ewp</path>
  </project>

  <batchBuild/>
</workspace>
