<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_eusart_spi_secondary_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_eusart_spi_secondary_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_eusart_spi_secondary_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_eusart_spi_secondary_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_eusart_spi_secondary_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
