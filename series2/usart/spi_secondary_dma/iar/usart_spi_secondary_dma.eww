<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG21_usart_spi_secondary_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_usart_spi_secondary_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_usart_spi_secondary_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG23_usart_spi_secondary_dma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
