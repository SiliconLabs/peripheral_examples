<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32xG21_usart_spi_slave_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
