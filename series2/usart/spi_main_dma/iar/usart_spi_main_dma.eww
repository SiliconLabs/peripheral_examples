<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG21_usart_spi_main_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG21_usart_spi_main_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG22_usart_spi_main_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG24_usart_spi_main_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG27_usart_spi_main_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG23_usart_spi_main_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32ZG28_usart_spi_main_dma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
