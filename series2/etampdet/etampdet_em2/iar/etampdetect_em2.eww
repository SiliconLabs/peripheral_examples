<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG27_etampdetect_em2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG25_etampdetect_em2.ewp</path>
  </project>

  <batchBuild/>
</workspace>
