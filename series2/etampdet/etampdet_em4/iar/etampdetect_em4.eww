<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32FG25_etampdetect_em4.ewp</path>
  </project>

  <batchBuild/>
</workspace>
