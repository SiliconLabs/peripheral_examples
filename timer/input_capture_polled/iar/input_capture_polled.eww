<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_input_capture_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_input_capture_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
