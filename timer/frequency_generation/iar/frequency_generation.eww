<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_frequency_generation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_frequency_generation.ewp</path>
  </project>

  <batchBuild/>
</workspace>
