<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32PG12B_single_pulse_generation_DMA.ewp</path>
  </project>

  <batchBuild/>
</workspace>
