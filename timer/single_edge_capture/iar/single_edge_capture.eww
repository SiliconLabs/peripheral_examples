<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_single_edge_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_single_edge_capture.ewp</path>
  </project>

  <batchBuild/>
</workspace>
