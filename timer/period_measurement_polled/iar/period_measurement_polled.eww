<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_period_measurement_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_period_measurement_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
