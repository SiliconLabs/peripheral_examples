<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_switch_led_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_switch_led_polled.ewp</path>
  </project>

  <batchBuild/>
</workspace>
