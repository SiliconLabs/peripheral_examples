<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32MG1P_spi_slave.ewp</path>
  </project>

  <batchBuild/>
</workspace>
