# IAR project EFM32GG11_spi_master_dma_prs_letimer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG11B820F2048GL192
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32GG11B820F2048GL192
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFM32GG11_spi_master_dma_prs_letimer.bin
  ILINK.IlinkOutputFile: EFM32GG11_spi_master_dma_prs_letimer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG11B820F2048GL192
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11/Source/IAR/: startup_efm32gg11.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11/Source/: system_efm32gg11.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_emu.c em_cmu.c em_gpio.c em_usart.c em_ldma.c em_prs.c em_letimer.c
  group Source
    ../src/: main_s1_gg11.c
    ../: readme_gg11.txt
