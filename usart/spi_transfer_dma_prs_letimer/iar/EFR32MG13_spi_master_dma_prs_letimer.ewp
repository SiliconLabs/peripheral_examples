# IAR project EFR32MG13_spi_master_dma_prs_letimer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG13P632F512GM48 SiliconLaboratories EFR32MG13P632F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32MG13P632F512GM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG13\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG13_BRD4159A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFR32MG13P632F512GM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG13_spi_master_dma_prs_letimer.bin
  ILINK.IlinkOutputFile: EFR32MG13_spi_master_dma_prs_letimer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32MG13P632F512GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG13P/Source/IAR/: startup_efr32mg13p.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG13P/Source/: system_efr32mg13p.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_emu.c em_cmu.c em_gpio.c em_usart.c em_ldma.c em_prs.c em_letimer.c
  group Source
    ../src/: main_s1_pg1_efr.c
    ../: readme_pg1_efr.txt
