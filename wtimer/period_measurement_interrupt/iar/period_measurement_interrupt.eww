<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG12P_period_measurement_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_period_measurement_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_period_measurement_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_period_measurement_interrupt.ewp</path>
  </project>

  <batchBuild/>
</workspace>
