<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG12P_vdac_voltage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_vdac_voltage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_vdac_voltage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_vdac_voltage.ewp</path>
  </project>

  <batchBuild/>
</workspace>
