<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG12P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG11B_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11B_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_vdac_differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_vdac_differential.ewp</path>
  </project>

  <batchBuild/>
</workspace>
