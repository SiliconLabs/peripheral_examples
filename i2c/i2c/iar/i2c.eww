<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG14P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG14P_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG11_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_i2c.ewp</path>
  </project>

  <batchBuild/>
</workspace>
