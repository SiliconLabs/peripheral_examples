<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_wdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_wdog.ewp</path>
  </project>

  <batchBuild/>
</workspace>
