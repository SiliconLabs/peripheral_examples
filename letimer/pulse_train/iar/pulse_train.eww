<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_pulse_train.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_pulse_train.ewp</path>
  </project>

  <batchBuild/>
</workspace>
