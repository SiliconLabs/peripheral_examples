<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFR32BG1P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32G_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32GG_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32HG_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32LG_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12P_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1B_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12B_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32WG_one_shot_output_compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32ZG_one_shot_output_compare.ewp</path>
  </project>

  <batchBuild/>
</workspace>
