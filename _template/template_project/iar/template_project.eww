<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32PG12_template_project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12_template_project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12_template_project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12_template_project.ewp</path>
  </project>

  <batchBuild/>
</workspace>
