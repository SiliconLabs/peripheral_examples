# IAR project EFR32FG1P_adc_scan_rtc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG1P133F256GM48 SiliconLaboratories EFR32FG1P133F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32FG1P133F256GM48; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG1P\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32FG1_BRD4250A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFR32FG1P133F256GM48; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG1P_adc_scan_rtc.bin
  ILINK.IlinkOutputFile: EFR32FG1P_adc_scan_rtc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32FG1P133F256GM48; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG1P/Source/IAR/: startup_efr32fg1p.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG1P/Source/: system_efr32fg1p.c
  group emlib
    ../../../../../platform/emlib/src/: em_core.c em_cmu.c em_adc.c em_gpio.c em_system.c em_usart.c em_leuart.c em_rtc.c em_rtcc.c em_emu.c em_prs.c
  group Source
    ./: readme_Series1.txt
    ../src/: main_Series1.c
